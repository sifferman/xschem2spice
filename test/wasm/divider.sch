v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {lib/ipin.sym} 0 -40 0 0 {name=p1 lab=IN}
C {lib/res.sym} 0 -20 0 0 {name=R1 value=1k}
C {lib/res.sym} 0 20 0 0 {name=R2 value=2k}
C {lib/opin.sym} 0 0 0 0 {name=p2 lab=MID}
C {lib/opin.sym} 0 40 0 0 {name=p3 lab=GND}
