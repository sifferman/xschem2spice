v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {escaped_quote_template_nmos.sym} 0 0 0 0 {name=M1 W=1.2u}
C {lab_pin.sym} 20 -30 0 0 {name=p1 lab=D}
C {lab_pin.sym} -20 0 0 0 {name=p2 lab=G}
C {lab_pin.sym} 20 30 0 0 {name=p3 lab=S}
C {lab_pin.sym} 20 0 0 0 {name=p4 lab=VSS}
